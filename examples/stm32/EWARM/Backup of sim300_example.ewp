# IAR project Backup of sim300_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; HSE_VALUE=((uint32_t)12000000)
  ICCARM.CCIncludePath2: ../src; ../../src; ../StdPeriph_Lib/STM32F10x_StdPeriph_Driver\inc; ../StdPeriph_Lib/CMSIS\CM3\DeviceSupport\ST\STM32F10x
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: sim300_example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group CMSIS
    ../StdPeriph_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ../StdPeriph_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group sim300
    ../../src/: sim300.c
  group src
    ../src/: board.c main.c
  group StdPeriph_Driver
    ../StdPeriph_Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
